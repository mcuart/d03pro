# IAR project Project.ewp, settings and files
configuration STM32F429_439xx (ARM, debug)
  General.OGChipSelectEditMenu: STM32F439NI ST STM32F439NI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx; USE_STM324x9I_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM324x9I_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F427_437xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F437II ST STM32F437II
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F427_437xx; USE_STM324x7I_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM324x7I_EVAL
configuration STM32F40_41xxx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; USE_STM324xG_EVAL; USE_USB_OTG_FS; USE_USB_OTG_HS; USE_EMBEDDED_PHY
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL; ..\STemWinLibrary532\inc; ..\STemWinLibrary532\Config; ..\Demo; ..\UCOSIII\uC-CPU; ..\UCOSIII\uC-LIB; ..\UCOSIII\uCOS-III\Source; ..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\UCOSIII\uC-CPU\ARM-Cortex-M4\IAR; ..\UCOSIII\uCOS_CONFIG; ..\delay; ..\..\..\Utilities\Third_Party\fat_fs\inc; ..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Class\hid_cdc_wrapper\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\UCOSIII\UCOS_BSP; ..\..\..\Libraries\STM32_USB_HOST_Library\Class\HID\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: d03pro_stm8_stm32_v1.0.bin
  postbuild: $EXE_DIR$\aes128_base64_firmware.bat
  ILINK.IlinkKeepSymbols: flashloader_f0_bin; flashloader_f1_bin; flashloader_f2_bin; flashloader_f3_bin; flashloader_f4_bin; flashloader_f7_bin; flashloader_h7_bin; flashloader_L0_v1.1_bin; flashloader_L1_bin; flashloader_L4_bin; flashloader_g0_bin; flashloader_mm32_f0_bin; flashloader_mm32_f1_bin; flashloader_efm32_bin; flashloader_e501_bin; flashloader_mm32f0010_bin; flashloader_gd32f1_bin; flashloader_G4_bin
  ILINK.IlinkExtraOptions: --image_input ..\flashloader_f0.bin,flashloader_f0_bin,flashloader_f0_section,4; --image_input ..\flashloader_f1.bin,flashloader_f1_bin,flashloader_f1_section,4; --image_input ..\flashloader_f2.bin,flashloader_f2_bin,flashloader_f2_section,4; --image_input ..\flashloader_f3.bin,flashloader_f3_bin,flashloader_f3_section,4; --image_input ..\flashloader_f4.bin,flashloader_f4_bin,flashloader_f4_section,4; --image_input ..\flashloader_f7.bin,flashloader_f7_bin,flashloader_f7_section,4; --image_input ..\flashloader_h7.bin,flashloader_h7_bin,flashloader_h7_section,4; --image_input ..\flashloader_L0_v1.1.bin,flashloader_L0_v1.1_bin,flashloader_L0_section,4; --image_input ..\flashloader_L1.bin,flashloader_L1_bin,flashloader_L1_section,4; --image_input ..\flashloader_L4.bin,flashloader_L4_bin,flashloader_L4_section,4; --image_input ..\flashloader_g0.bin,flashloader_g0_bin,flashloader_g0_section,4; --image_input ..\flashloader_mm32_f0.bin,flashloader_mm32_f0_bin,flashloader_mm32_f0_section,4; --image_input ..\flashloader_mm32_f1.bin,flashloader_mm32_f1_bin,flashloader_mm32_f1_section,4; --image_input ..\flashloader_efm32.bin,flashloader_efm32_bin,flashloader_efm32_section,4; --image_input ..\flashloader_e501.bin,flashloader_e501_bin,flashloader_e501_section,4; --image_input ..\flashloader_mm32f0010.bin,flashloader_mm32f0010_bin,flashloader_mm32f0010_section,4; --image_input ..\flashloader_gd32f1.bin,flashloader_gd32f1_bin,flashloader_gd32f1_section,4; --image_input ..\flashloader_G4.bin,flashloader_G4_bin,flashloader_G4_section,4
configuration STM32F401xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F401VC ST STM32F401VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common
configuration STM32F411xE (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F411xE
  ICCARM.CCIncludePath2: as above
configuration STM32F446xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F446ZE ST STM32F446ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F446xx
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc
configuration STM32F469_479xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F479NI ST STM32F479NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F469_479xx
configuration STM32F410xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F410RB ST STM32F410RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F410xx
  ICCARM.CCIncludePath2: as above
configuration STM32F412xG (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F412ZG ST STM32F412ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F412xG
  ICCARM.CCIncludePath2: as above
configuration STM32F413_423xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F413ZH ST STM32F413ZH
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F413_423xx
  ICCARM.CCIncludePath2: as above
  group AES
    ../: AES.c
  group cJSON
    ../cJSON/: cJSON.c
  group CMSIS
    ../: system_stm32f4xx.c
  group Doc
    ../: readme.txt
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xx.s startup_stm32f40_41xxx.s startup_stm32f410xx.s startup_stm32f411xe.s startup_stm32f412xg.s startup_stm32f413_423xx.s startup_stm32f427_437xx.s startup_stm32f429_439xx.s startup_stm32f446xx.s startup_stm32f469_479xx.s
  group FAT_FS
    ../: diskio.c ff.c
    ../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_sdio_sd.c
  group ICP
    ../: icp.c
  group STemwin_V5.22
    ../STemWinLibrary532/OS/: GUI_X_uCOS.c
    ../STemWinLibrary532/Config/: GUIConf_stm3240g_eval.c LCDConf_stm3240g_eval.c
    ../STemWinLibrary532/Lib/: STemWin522_CM4_OS_IAR.a
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SWD
    ../: DAP.c SW_DP.c SWD_main.c use_flashloader.c utils.c
  group SWIM
    ../: Swim_TIM2_CH1_CH2_TIM5_CH3_UCOS-III_B.c Swim_TIM4_CH1_CH2_TIM3_CH3_UCOS-III_A.c
  group UCOS_III/BSP
    ../UCOSIII/UCOS_BSP/: bsp.c bsp_os.c
  group UCOS_III/CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOS_III/CPU
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/IAR/: cpu_a.asm cpu_c.c
    ../UCOSIII/uC-CPU/: cpu_core.c
  group UCOS_III/LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group UCOS_III/PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOS_III/UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group USB
    ../: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_desc_msc.c usbd_usr.c usbh_usr.c
  group USB_Device_Library/Class/CDC
    ../../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB_Device_Library/Class/HID
    ../../../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
  group USB_Device_Library/Class/HID_CDC_WRAPPER
    ../../../Libraries/STM32_USB_Device_Library/Class/hid_cdc_wrapper/src/: usbd_hid_cdc_wrapper.c
  group USB_Device_Library/Class/MSC
    ../../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c usbd_storage_msd.c
  group USB_Device_Library/Core
    ../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB_HOST_Library/Class/HID
    ../../../Libraries/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c
  group USB_HOST_Library/Core
    ../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_OTG_Driver
    ../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c
  group User
    ../: config.c GUI_X_Touch.c key.c main.c spi_flash.c stm32f4xx_it.c Touch.c
    ../delay/: delay.c
    ../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval_lcd.c
  group User/bmp
    ../: chip.c update.c usb.c
  group User/EMWIN_DEMO
    ../Demo/: GUIDEMO.c GUIDEMO.h GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group User/font
    ../: Audiowide32.c lizhicaiyun.c songti16.c songti17.c
